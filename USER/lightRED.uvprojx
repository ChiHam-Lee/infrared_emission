# Keil uVision project lightRED.uvprojx, settings and files
target Target 1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103VB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: lightRED
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\Source\System\delay;..\Source\System\sys;..\Source\Drivers\adc;..\Source\Drivers\exti;..\Source\Drivers\led;..\Source\Drivers\usart
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: STM32F10x.s
  group USER
    ./: main.c
  group devices
    ../Source/Drivers/adc/: adc.c
    ../Source/Drivers/exti/: exti.c
    ../Source/Drivers/led/: led.c
    ../Source/Drivers/usart/: usart.c
  group SYSTEM
    ../Source/System/delay/: delay.c
    ../Source/System/sys/: sys.c
